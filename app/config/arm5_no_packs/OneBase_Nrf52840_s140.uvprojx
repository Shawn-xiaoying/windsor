# Keil uVision project OneBase_Nrf52840_s140.uvprojx, settings and files
target WAP-2-411 Oxford (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: WAP-2-411-Oxford +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056    FLOAT_ABI_HARD NRF52840_XXAA    NRF_DFU_SVCI_ENABLED  NRF_DFU_TRANSPORT_BLE=1    NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048   CONTROLLER_TYPE =HBOT_CONTROLLER    NRF_DFU_TRANSPORT_BLE=1  BL_SETTINGS_ACCESS_ONLY   HBOT_MOD_1_3_ATA
  c misc: --reduce_paths
  c include: ..\..\..\external\NordicSdk_17_0_2\components;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_advertising;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_dtm;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_link_ctx_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_racp;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ancs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ans_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cts_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dis;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_gls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hts;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_tps;..\..\..\external\NordicSdk_17_0_2\components\ble\common;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_gatt;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_qwr;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\boards;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_flags;..\..\..\external\NordicSdk_17_0_2\components\libraries\balloc;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bsp;..\..\..\external\NordicSdk_17_0_2\components\libraries\button;..\..\..\external\NordicSdk_17_0_2\components\libraries\cli;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc16;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc32;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense_drv;..\..\..\external\NordicSdk_17_0_2\components\libraries\delay;..\..\..\external\NordicSdk_17_0_2\components\libraries\ecc;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_section_vars;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_task_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\..\external\NordicSdk_17_0_2\components\libraries\gfx;..\..\..\external\NordicSdk_17_0_2\components\libraries\gpiote;..\..\..\external\NordicSdk_17_0_2\components\libraries\hardfault;..\..\..\external\NordicSdk_17_0_2\components\libraries\hci;..\..\..\external\NordicSdk_17_0_2\components\libraries\led_softblink;..\..\..\external\NordicSdk_17_0_2\components\libraries\log;..\..\..\external\NordicSdk_17_0_2\components\libraries\log\src;..\..\..\external\NordicSdk_17_0_2\components\libraries\low_power_pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\mem_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\memobj;..\..\..\external\NordicSdk_17_0_2\components\libraries\mpu;..\..\..\external\NordicSdk_17_0_2\components\libraries\mutex;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwr_mgmt;..\..\..\external\NordicSdk_17_0_2\components\libraries\queue;..\..\..\external\NordicSdk_17_0_2\components\libraries\ringbuf;..\..\..\external\NordicSdk_17_0_2\components\libraries\scheduler;..\..\..\external\NordicSdk_17_0_2\components\libraries\sdcard;..\..\..\external\NordicSdk_17_0_2\components\libraries\slip;..\..\..\external\NordicSdk_17_0_2\components\libraries\sortlist;..\..\..\external\NordicSdk_17_0_2\components\libraries\spi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\stack_guard;..\..\..\external\NordicSdk_17_0_2\components\libraries\strerror;..\..\..\external\NordicSdk_17_0_2\components\libraries\svc;..\..\..\external\NordicSdk_17_0_2\components\libraries\timer;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_sensor;..\..\..\external\NordicSdk_17_0_2\components\libraries\uart;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\audio;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc\acm;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\generic;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\kbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\mouse;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\msc;..\..\..\external\NordicSdk_17_0_2\components\libraries\util;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ac_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\common;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\hs_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\launchapp;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\text;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\uri;..\..\..\external\NordicSdk_17_0_2\components\nfc\platform;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\apdu;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\cc_file;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\tlv;..\..\..\external\NordicSdk_17_0_2\components\softdevice\common;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers\nrf52;..\..\..\external\NordicSdk_17_0_2\external\fprintf;..\..\..\external\NordicSdk_17_0_2\external\segger_rtt;..\..\..\external\NordicSdk_17_0_2\external\utf_converter;..\..\..\external\NordicSdk_17_0_2\integration\nrfx;..\..\..\external\NordicSdk_17_0_2\integration\nrfx\legacy;..\..\..\external\NordicSdk_17_0_2\modules\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\drivers\include;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\hal;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\src\projects;..\..\src\projects\WAP-2-411 Oxford;..\..\src\projects\WAP-2-411 Oxford\app;..\..\src\projects\WAP-2-411 Oxford\bsp;..\..\src\config;..\..\src\session;..\..\src\user_app;..\..\src\user_ble;..\..\src\user_bsp;..\..\src\user_bsp\tiny-AES128;..\..\src\user_drivers;..\..\src\session_sharing;..\..\src\efsm;..\..\src\session_sharing;..\..\src\cmds;..\..\src\tuya_cmd_management
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\external\NordicSdk_17_0_2\components;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_advertising;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_dtm;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_link_ctx_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_racp;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ancs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ans_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cts_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dis;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_gls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hts;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_tps;..\..\..\external\NordicSdk_17_0_2\components\ble\common;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_gatt;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_qwr;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\boards;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_flags;..\..\..\external\NordicSdk_17_0_2\components\libraries\balloc;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bsp;..\..\..\external\NordicSdk_17_0_2\components\libraries\button;..\..\..\external\NordicSdk_17_0_2\components\libraries\cli;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc16;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc32;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense_drv;..\..\..\external\NordicSdk_17_0_2\components\libraries\delay;..\..\..\external\NordicSdk_17_0_2\components\libraries\ecc;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_section_vars;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_task_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\..\external\NordicSdk_17_0_2\components\libraries\gfx;..\..\..\external\NordicSdk_17_0_2\components\libraries\gpiote;..\..\..\external\NordicSdk_17_0_2\components\libraries\hardfault;..\..\..\external\NordicSdk_17_0_2\components\libraries\hci;..\..\..\external\NordicSdk_17_0_2\components\libraries\led_softblink;..\..\..\external\NordicSdk_17_0_2\components\libraries\log;..\..\..\external\NordicSdk_17_0_2\components\libraries\log\src;..\..\..\external\NordicSdk_17_0_2\components\libraries\low_power_pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\mem_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\memobj;..\..\..\external\NordicSdk_17_0_2\components\libraries\mpu;..\..\..\external\NordicSdk_17_0_2\components\libraries\mutex;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwr_mgmt;..\..\..\external\NordicSdk_17_0_2\components\libraries\queue;..\..\..\external\NordicSdk_17_0_2\components\libraries\ringbuf;..\..\..\external\NordicSdk_17_0_2\components\libraries\scheduler;..\..\..\external\NordicSdk_17_0_2\components\libraries\sdcard;..\..\..\external\NordicSdk_17_0_2\components\libraries\slip;..\..\..\external\NordicSdk_17_0_2\components\libraries\sortlist;..\..\..\external\NordicSdk_17_0_2\components\libraries\spi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\stack_guard;..\..\..\external\NordicSdk_17_0_2\components\libraries\strerror;..\..\..\external\NordicSdk_17_0_2\components\libraries\svc;..\..\..\external\NordicSdk_17_0_2\components\libraries\timer;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_sensor;..\..\..\external\NordicSdk_17_0_2\components\libraries\uart;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\audio;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc\acm;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\generic;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\kbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\mouse;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\msc;..\..\..\external\NordicSdk_17_0_2\components\libraries\util;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ac_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\common;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\hs_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\launchapp;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\text;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\uri;..\..\..\external\NordicSdk_17_0_2\components\nfc\platform;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\apdu;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\cc_file;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\tlv;..\..\..\external\NordicSdk_17_0_2\components\softdevice\common;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers\nrf52;..\..\..\external\NordicSdk_17_0_2\external\fprintf;..\..\..\external\NordicSdk_17_0_2\external\segger_rtt;..\..\..\external\NordicSdk_17_0_2\external\utf_converter;..\..\..\external\NordicSdk_17_0_2\integration\nrfx;..\..\..\external\NordicSdk_17_0_2\integration\nrfx\legacy;..\..\..\external\NordicSdk_17_0_2\modules\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\drivers\include;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20009aa0 size 0x36560
  link misc: --diag_suppress 6330
  group user_app
    ../../src/user_app/: app_cfg_cmd.c comm_lib.c mt_ble_adv.c mt_cst_protocol.c mt_logic.c wap-1-100-windsor-master-protocol.h fstorage.c fstorage.h main.c app_multi_user_service_cfg.c app_multi_user_service_cfg.h
  group user_ble
    ../../src/user_ble/: ble_ctcs.c mt_ble_cfg.c mt_ble_service.c mt_s_public.c
  group user_bsp
    ../../src/user_bsp/: mt_serial.c
    ../../src/user_bsp/tiny-AES128/: aes.c
  group user_driver
    ../../src/user_drivers/: mt_wdt.c
  group Board Definition
    ../../../external/NordicSdk_17_0_2/components/boards/: boards.c
  group Board Support
    ../../../external/NordicSdk_17_0_2/components/libraries/bsp/: bsp.c bsp_btn_ble.c
  group UTF8/UTF16 converter
    ../../../external/NordicSdk_17_0_2/external/utf_converter/: utf.c
  group nRF_BLE
    ../../../external/NordicSdk_17_0_2/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../external/NordicSdk_17_0_2/components/ble/ble_advertising/: ble_advertising.c
    ../../../external/NordicSdk_17_0_2/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../external/NordicSdk_17_0_2/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../external/NordicSdk_17_0_2/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../../external/NordicSdk_17_0_2/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
  group nRF_BLE_Services
    ../../../external/NordicSdk_17_0_2/components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../external/NordicSdk_17_0_2/components/ble/ble_services/ble_hids/: ble_hids.c
  group nRF_Drivers
    ../../../external/NordicSdk_17_0_2/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../../external/NordicSdk_17_0_2/modules/nrfx/soc/: nrfx_atomic.c
    ../../../external/NordicSdk_17_0_2/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    ../../../external/NordicSdk_17_0_2/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../../external/NordicSdk_17_0_2/components/libraries/button/: app_button.c
    ../../../external/NordicSdk_17_0_2/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../external/NordicSdk_17_0_2/components/libraries/fifo/: app_fifo.c
    ../../../external/NordicSdk_17_0_2/components/libraries/scheduler/: app_scheduler.c
    ../../../external/NordicSdk_17_0_2/components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../external/NordicSdk_17_0_2/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../external/NordicSdk_17_0_2/components/libraries/hardfault/: hardfault_implementation.c
    ../../../external/NordicSdk_17_0_2/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../external/NordicSdk_17_0_2/components/libraries/atomic_flags/: nrf_atflags.c
    ../../../external/NordicSdk_17_0_2/components/libraries/atomic/: nrf_atomic.c
    ../../../external/NordicSdk_17_0_2/components/libraries/balloc/: nrf_balloc.c
    ../../../external/NordicSdk_17_0_2/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../external/NordicSdk_17_0_2/components/libraries/memobj/: nrf_memobj.c
    ../../../external/NordicSdk_17_0_2/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../external/NordicSdk_17_0_2/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../external/NordicSdk_17_0_2/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../external/NordicSdk_17_0_2/components/libraries/sortlist/: nrf_sortlist.c
    ../../../external/NordicSdk_17_0_2/components/libraries/strerror/: nrf_strerror.c
    ../../../external/NordicSdk_17_0_2/components/libraries/fds/: fds.c
    ../../../external/NordicSdk_17_0_2/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
  group nRF_Log
    ../../../external/NordicSdk_17_0_2/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../external/NordicSdk_17_0_2/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../external/NordicSdk_17_0_2/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_SVC
    ../../../external/NordicSdk_17_0_2/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_DFU
    ../../../external/NordicSdk_17_0_2/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_unbonded.c
  group WAP-2-411 Oxford
    ../../src/projects/WAP-2-411 Oxford/app/: air_conditione_communication.c app_task.c HBOT_uart_cmd.c implemention_app_cfg_cmd.c sensor_communication.c logging_rw_implent.c session_parameters_check_implent.c app_session_set_cmd_management.c app_session_set_cmd_management.h app_set_cmd_management.c app_set_cmd_management.h
    ../../src/projects/WAP-2-411 Oxford/bsp/: mt_gpio.c
  group WAP-2-431 Sauna
    ../../src/projects/WAP-2-431 Sauna/app/tuya/: mcu_api.c protocol.c system.c
    ../../src/projects/WAP-2-431 Sauna/app/: dpid_map_c.c implemention_app_cfg_cmd.c logging_rw_implent.c session_parameters_check_implent.c app_task_user_state_machine.c
    ../../src/projects/WAP-2-431 Sauna/bsp/: mt_gpio.c
  group WAP-2-441 Edinburgh
    ../../src/projects/WAP-2-441 Edinburgh/app/: dpid_map_c.c implemention_app_cfg_cmd.c logging_rw_implent.c session_parameters_check_implent.c app_task_user_state_machine.c
    ../../src/projects/WAP-2-441 Edinburgh/app/tuya/: mcu_api.c protocol.c system.c
    ../../src/projects/WAP-2-441 Edinburgh/bsp/: mt_gpio.c
  group WAP-2-451 Bristol
    ../../src/projects/WAP-2-451 Bristol/app/: app_task_user_state_machine.c dpid_map_c.c implemention_app_cfg_cmd.c logging_rw_implent.c session_parameters_check_implent.c
    ../../src/projects/WAP-2-451 Bristol/app/tuya/: mcu_api.c protocol.c system.c
    ../../src/projects/WAP-2-451 Bristol/bsp/: mt_gpio.c
  group WAP-2-413 London
    ../../src/projects/WAP-2-413 London/app/: app_task_user_state_machine.c dpid_map_c.c implemention_app_cfg_cmd.c logging_rw_implent.c session_parameters_check_implent.c
    ../../src/projects/WAP-2-413 London/app/tuya/: mcu_api.c protocol.c system.c
    ../../src/projects/WAP-2-413 London/bsp/: mt_gpio.c
  group session
    ../../src/session/: preparation_stage.c preparation_stage.h session.c session.h session_log.c session_log.h session_run_stage.c session_run_stage.h set_get_session.c set_get_session.h session_parameters_check.h session_parameters_check.c session_parameters_check_implent.h session_log_def.h
  group efsm
    ../../src/efsm/: efsm.c efsm.h efsm_config.h efsm_hal.c efsm_hal.h
  group tuya_cmd_management
    ../../src/tuya_cmd_management/: tuya_cmd_send_task.c tuya_cmd_send_task.h heart_cmd.h heart_cmd.c tuya_recv_data_task.h tuya_recv_data_task.c upload_up_cmd.c upload_up_cmd.h controller_connection_status_task.c controller_connection_status_task.h set_data_06_cmd.c set_data_06_cmd.h query_state_08_cmd.c query_state_08_cmd.h device_info_cmd.c device_info_cmd.h
  group cmds
    ../../src/cmds/: app_set_cmd_management.h app_set_cmd_management.c proactively_upload_data_management.c proactively_upload_data_management.h app_session_set_cmd_management.c app_session_set_cmd_management.h
  group session_sharging
    ../../src/session_sharing/: bluetooth_connection_management.c bluetooth_connection_management.h session_sharing_cmd.h session_sharing_cmd.c session_sharing_user_list.h session_sharing_user_list.c
target flash_s140_nrf52_7.2.0_softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: s140_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002ae8 size 0x3d288
  link misc: --diag_suppress 6330
target WAP-2-431 Sauna (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: WAP-2-431-Sauna +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056   FLOAT_ABI_HARD NRF52840_XXAA    NRF_DFU_SVCI_ENABLED  NRF_DFU_TRANSPORT_BLE=1    NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048   CONTROLLER_TYPE =SAUNA_CONTROLLER   NRF_DFU_TRANSPORT_BLE=1  BL_SETTINGS_ACCESS_ONLY   DEBUG
  c include: ..\..\..\config;..\..\..\external\NordicSdk_17_0_2\components;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_advertising;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_dtm;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_link_ctx_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_racp;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ancs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ans_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cts_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dis;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_gls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hts;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_tps;..\..\..\external\NordicSdk_17_0_2\components\ble\common;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_gatt;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_qwr;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\boards;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_flags;..\..\..\external\NordicSdk_17_0_2\components\libraries\balloc;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bsp;..\..\..\external\NordicSdk_17_0_2\components\libraries\button;..\..\..\external\NordicSdk_17_0_2\components\libraries\cli;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc16;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc32;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense_drv;..\..\..\external\NordicSdk_17_0_2\components\libraries\delay;..\..\..\external\NordicSdk_17_0_2\components\libraries\ecc;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_section_vars;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_task_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\..\external\NordicSdk_17_0_2\components\libraries\gfx;..\..\..\external\NordicSdk_17_0_2\components\libraries\gpiote;..\..\..\external\NordicSdk_17_0_2\components\libraries\hardfault;..\..\..\external\NordicSdk_17_0_2\components\libraries\hci;..\..\..\external\NordicSdk_17_0_2\components\libraries\led_softblink;..\..\..\external\NordicSdk_17_0_2\components\libraries\log;..\..\..\external\NordicSdk_17_0_2\components\libraries\log\src;..\..\..\external\NordicSdk_17_0_2\components\libraries\low_power_pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\mem_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\memobj;..\..\..\external\NordicSdk_17_0_2\components\libraries\mpu;..\..\..\external\NordicSdk_17_0_2\components\libraries\mutex;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwr_mgmt;..\..\..\external\NordicSdk_17_0_2\components\libraries\queue;..\..\..\external\NordicSdk_17_0_2\components\libraries\ringbuf;..\..\..\external\NordicSdk_17_0_2\components\libraries\scheduler;..\..\..\external\NordicSdk_17_0_2\components\libraries\sdcard;..\..\..\external\NordicSdk_17_0_2\components\libraries\slip;..\..\..\external\NordicSdk_17_0_2\components\libraries\sortlist;..\..\..\external\NordicSdk_17_0_2\components\libraries\spi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\stack_guard;..\..\..\external\NordicSdk_17_0_2\components\libraries\strerror;..\..\..\external\NordicSdk_17_0_2\components\libraries\svc;..\..\..\external\NordicSdk_17_0_2\components\libraries\timer;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_sensor;..\..\..\external\NordicSdk_17_0_2\components\libraries\uart;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\audio;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc\acm;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\generic;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\kbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\mouse;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\msc;..\..\..\external\NordicSdk_17_0_2\components\libraries\util;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ac_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\common;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\hs_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\launchapp;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\text;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\uri;..\..\..\external\NordicSdk_17_0_2\components\nfc\platform;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\apdu;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\cc_file;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\tlv;..\..\..\external\NordicSdk_17_0_2\components\softdevice\common;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers\nrf52;..\..\..\external\NordicSdk_17_0_2\external\fprintf;..\..\..\external\NordicSdk_17_0_2\external\segger_rtt;..\..\..\external\NordicSdk_17_0_2\external\utf_converter;..\..\..\external\NordicSdk_17_0_2\integration\nrfx;..\..\..\external\NordicSdk_17_0_2\integration\nrfx\legacy;..\..\..\external\NordicSdk_17_0_2\modules\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\drivers\include;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\hal;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\src\projects;..\..\src\session;..\..\src\efsm;..\..\src\tuya_cmd_management;..\..\src\cmds;..\..\src\projects\WAP-2-431 Sauna;..\..\src\projects\WAP-2-431 Sauna\app\tuya;..\..\src\projects\WAP-2-431 Sauna\app;..\..\src\projects\WAP-2-431 Sauna\bsp;..\..\src\config;..\..\src\user_app;..\..\src\user_ble;..\..\src\user_bsp\tiny-AES128;..\..\src\user_bsp;..\..\src\user_drivers;..\..\src\session_sharing
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT  __HEAP_SIZE=8192  __STACK_SIZE=8192
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20009aa0 size 0x36560
  link misc: --diag_suppress 6330
target WAP-2-441 Edinburgh (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: WAP-2-441-Edinburgh +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056   FLOAT_ABI_HARD NRF52840_XXAA    NRF_DFU_SVCI_ENABLED  NRF_DFU_TRANSPORT_BLE=1    NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048   CONTROLLER_TYPE =COOLING_WATER_MACHINE   NRF_DFU_TRANSPORT_BLE=1  BL_SETTINGS_ACCESS_ONLY
  c include: ..\..\..\external\NordicSdk_17_0_2\components;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_advertising;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_dtm;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_link_ctx_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_racp;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ancs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ans_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cts_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dis;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_gls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hts;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_tps;..\..\..\external\NordicSdk_17_0_2\components\ble\common;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_gatt;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_qwr;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\boards;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_flags;..\..\..\external\NordicSdk_17_0_2\components\libraries\balloc;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bsp;..\..\..\external\NordicSdk_17_0_2\components\libraries\button;..\..\..\external\NordicSdk_17_0_2\components\libraries\cli;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc16;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc32;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense_drv;..\..\..\external\NordicSdk_17_0_2\components\libraries\delay;..\..\..\external\NordicSdk_17_0_2\components\libraries\ecc;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_section_vars;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_task_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\..\external\NordicSdk_17_0_2\components\libraries\gfx;..\..\..\external\NordicSdk_17_0_2\components\libraries\gpiote;..\..\..\external\NordicSdk_17_0_2\components\libraries\hardfault;..\..\..\external\NordicSdk_17_0_2\components\libraries\hci;..\..\..\external\NordicSdk_17_0_2\components\libraries\led_softblink;..\..\..\external\NordicSdk_17_0_2\components\libraries\log;..\..\..\external\NordicSdk_17_0_2\components\libraries\log\src;..\..\..\external\NordicSdk_17_0_2\components\libraries\low_power_pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\mem_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\memobj;..\..\..\external\NordicSdk_17_0_2\components\libraries\mpu;..\..\..\external\NordicSdk_17_0_2\components\libraries\mutex;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwr_mgmt;..\..\..\external\NordicSdk_17_0_2\components\libraries\queue;..\..\..\external\NordicSdk_17_0_2\components\libraries\ringbuf;..\..\..\external\NordicSdk_17_0_2\components\libraries\scheduler;..\..\..\external\NordicSdk_17_0_2\components\libraries\sdcard;..\..\..\external\NordicSdk_17_0_2\components\libraries\slip;..\..\..\external\NordicSdk_17_0_2\components\libraries\sortlist;..\..\..\external\NordicSdk_17_0_2\components\libraries\spi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\stack_guard;..\..\..\external\NordicSdk_17_0_2\components\libraries\strerror;..\..\..\external\NordicSdk_17_0_2\components\libraries\svc;..\..\..\external\NordicSdk_17_0_2\components\libraries\timer;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_sensor;..\..\..\external\NordicSdk_17_0_2\components\libraries\uart;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\audio;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc\acm;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\generic;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\kbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\mouse;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\msc;..\..\..\external\NordicSdk_17_0_2\components\libraries\util;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ac_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\common;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\hs_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\launchapp;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\text;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\uri;..\..\..\external\NordicSdk_17_0_2\components\nfc\platform;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\apdu;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\cc_file;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\tlv;..\..\..\external\NordicSdk_17_0_2\components\softdevice\common;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers\nrf52;..\..\..\external\NordicSdk_17_0_2\external\fprintf;..\..\..\external\NordicSdk_17_0_2\external\segger_rtt;..\..\..\external\NordicSdk_17_0_2\external\utf_converter;..\..\..\external\NordicSdk_17_0_2\integration\nrfx;..\..\..\external\NordicSdk_17_0_2\integration\nrfx\legacy;..\..\..\external\NordicSdk_17_0_2\modules\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\drivers\include;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\hal;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\src\config;..\..\src\user_app;..\..\src\user_ble;..\..\src\user_bsp;..\..\src\user_bsp\tiny-AES128;..\..\src\user_drivers;..\..\src\projects;..\..\src\session;..\..\src\projects\WAP-2-441 Edinburgh;..\..\src\projects\WAP-2-441 Edinburgh\app\tuya;..\..\src\projects\WAP-2-441 Edinburgh\bsp;..\..\src\projects\WAP-2-441 Edinburgh\app;..\..\src\cmds;..\..\src\tuya_cmd_management;..\..\src\efsm;..\..\src\session_sharing
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20009aa0 size 0x36560
  link misc: --diag_suppress 6330
target WAP-2-451 Bristol (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: WAP-2-451-Bristol +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056   FLOAT_ABI_HARD NRF52840_XXAA    NRF_DFU_SVCI_ENABLED  NRF_DFU_TRANSPORT_BLE=1    NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048   CONTROLLER_TYPE =RED_LIGHT   NRF_DFU_TRANSPORT_BLE=1  BL_SETTINGS_ACCESS_ONLY
  c include: ..\..\..\external\NordicSdk_17_0_2\components;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_advertising;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_dtm;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_link_ctx_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_racp;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ancs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ans_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cts_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dis;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_gls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hts;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_tps;..\..\..\external\NordicSdk_17_0_2\components\ble\common;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_gatt;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_qwr;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\boards;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_flags;..\..\..\external\NordicSdk_17_0_2\components\libraries\balloc;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bsp;..\..\..\external\NordicSdk_17_0_2\components\libraries\button;..\..\..\external\NordicSdk_17_0_2\components\libraries\cli;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc16;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc32;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense_drv;..\..\..\external\NordicSdk_17_0_2\components\libraries\delay;..\..\..\external\NordicSdk_17_0_2\components\libraries\ecc;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_section_vars;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_task_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\..\external\NordicSdk_17_0_2\components\libraries\gfx;..\..\..\external\NordicSdk_17_0_2\components\libraries\gpiote;..\..\..\external\NordicSdk_17_0_2\components\libraries\hardfault;..\..\..\external\NordicSdk_17_0_2\components\libraries\hci;..\..\..\external\NordicSdk_17_0_2\components\libraries\led_softblink;..\..\..\external\NordicSdk_17_0_2\components\libraries\log;..\..\..\external\NordicSdk_17_0_2\components\libraries\log\src;..\..\..\external\NordicSdk_17_0_2\components\libraries\low_power_pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\mem_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\memobj;..\..\..\external\NordicSdk_17_0_2\components\libraries\mpu;..\..\..\external\NordicSdk_17_0_2\components\libraries\mutex;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwr_mgmt;..\..\..\external\NordicSdk_17_0_2\components\libraries\queue;..\..\..\external\NordicSdk_17_0_2\components\libraries\ringbuf;..\..\..\external\NordicSdk_17_0_2\components\libraries\scheduler;..\..\..\external\NordicSdk_17_0_2\components\libraries\sdcard;..\..\..\external\NordicSdk_17_0_2\components\libraries\slip;..\..\..\external\NordicSdk_17_0_2\components\libraries\sortlist;..\..\..\external\NordicSdk_17_0_2\components\libraries\spi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\stack_guard;..\..\..\external\NordicSdk_17_0_2\components\libraries\strerror;..\..\..\external\NordicSdk_17_0_2\components\libraries\svc;..\..\..\external\NordicSdk_17_0_2\components\libraries\timer;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_sensor;..\..\..\external\NordicSdk_17_0_2\components\libraries\uart;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\audio;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc\acm;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\generic;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\kbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\mouse;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\msc;..\..\..\external\NordicSdk_17_0_2\components\libraries\util;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ac_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\common;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\hs_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\launchapp;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\text;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\uri;..\..\..\external\NordicSdk_17_0_2\components\nfc\platform;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\apdu;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\cc_file;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\tlv;..\..\..\external\NordicSdk_17_0_2\components\softdevice\common;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers\nrf52;..\..\..\external\NordicSdk_17_0_2\external\fprintf;..\..\..\external\NordicSdk_17_0_2\external\segger_rtt;..\..\..\external\NordicSdk_17_0_2\external\utf_converter;..\..\..\external\NordicSdk_17_0_2\integration\nrfx;..\..\..\external\NordicSdk_17_0_2\integration\nrfx\legacy;..\..\..\external\NordicSdk_17_0_2\modules\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\drivers\include;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\hal;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\src\config;..\..\src\user_app;..\..\src\user_ble;..\..\src\user_bsp;..\..\src\user_drivers;..\..\src\user_bsp\tiny-AES128;..\..\src\projects;..\..\src\session;..\..\src\cmds;..\..\src\tuya_cmd_management;..\..\src\efsm;..\..\src\projects\WAP-2-451 Bristol;..\..\src\projects\WAP-2-451 Bristol\app;..\..\src\projects\WAP-2-451 Bristol\app\tuya;..\..\src\projects\WAP-2-451 Bristol\bsp;..\..\src\session_sharing
  asm define: as above
  asm misc: as above
  asm include: ..\..\..\config;..\..\..\external\NordicSdk_17_0_2\components;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_advertising;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_dtm;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_link_ctx_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_racp;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ancs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ans_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cts_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dis;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_gls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hts;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_tps;..\..\..\external\NordicSdk_17_0_2\components\ble\common;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_gatt;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_qwr;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\boards;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_flags;..\..\..\external\NordicSdk_17_0_2\components\libraries\balloc;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bsp;..\..\..\external\NordicSdk_17_0_2\components\libraries\button;..\..\..\external\NordicSdk_17_0_2\components\libraries\cli;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc16;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc32;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense_drv;..\..\..\external\NordicSdk_17_0_2\components\libraries\delay;..\..\..\external\NordicSdk_17_0_2\components\libraries\ecc;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_section_vars;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_task_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\..\external\NordicSdk_17_0_2\components\libraries\gfx;..\..\..\external\NordicSdk_17_0_2\components\libraries\gpiote;..\..\..\external\NordicSdk_17_0_2\components\libraries\hardfault;..\..\..\external\NordicSdk_17_0_2\components\libraries\hci;..\..\..\external\NordicSdk_17_0_2\components\libraries\led_softblink;..\..\..\external\NordicSdk_17_0_2\components\libraries\log;..\..\..\external\NordicSdk_17_0_2\components\libraries\log\src;..\..\..\external\NordicSdk_17_0_2\components\libraries\low_power_pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\mem_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\memobj;..\..\..\external\NordicSdk_17_0_2\components\libraries\mpu;..\..\..\external\NordicSdk_17_0_2\components\libraries\mutex;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwr_mgmt;..\..\..\external\NordicSdk_17_0_2\components\libraries\queue;..\..\..\external\NordicSdk_17_0_2\components\libraries\ringbuf;..\..\..\external\NordicSdk_17_0_2\components\libraries\scheduler;..\..\..\external\NordicSdk_17_0_2\components\libraries\sdcard;..\..\..\external\NordicSdk_17_0_2\components\libraries\slip;..\..\..\external\NordicSdk_17_0_2\components\libraries\sortlist;..\..\..\external\NordicSdk_17_0_2\components\libraries\spi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\stack_guard;..\..\..\external\NordicSdk_17_0_2\components\libraries\strerror;..\..\..\external\NordicSdk_17_0_2\components\libraries\svc;..\..\..\external\NordicSdk_17_0_2\components\libraries\timer;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_sensor;..\..\..\external\NordicSdk_17_0_2\components\libraries\uart;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\audio;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc\acm;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\generic;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\kbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\mouse;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\msc;..\..\..\external\NordicSdk_17_0_2\components\libraries\util;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ac_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\common;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\hs_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\launchapp;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\text;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\uri;..\..\..\external\NordicSdk_17_0_2\components\nfc\platform;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\apdu;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\cc_file;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\tlv;..\..\..\external\NordicSdk_17_0_2\components\softdevice\common;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers\nrf52;..\..\..\external\NordicSdk_17_0_2\external\fprintf;..\..\..\external\NordicSdk_17_0_2\external\segger_rtt;..\..\..\external\NordicSdk_17_0_2\external\utf_converter;..\..\..\external\NordicSdk_17_0_2\integration\nrfx;..\..\..\external\NordicSdk_17_0_2\integration\nrfx\legacy;..\..\..\external\NordicSdk_17_0_2\modules\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\drivers\include;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\hal;..\..\src\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20009aa0 size 0x36560
  link misc: --diag_suppress 6330
target WAP-2-413 London (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: WAP-2-413-London +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056   FLOAT_ABI_HARD NRF52840_XXAA    NRF_DFU_SVCI_ENABLED  NRF_DFU_TRANSPORT_BLE=1    NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=2048 __STACK_SIZE=2048   CONTROLLER_TYPE =RED_LIGHT   NRF_DFU_TRANSPORT_BLE=1  BL_SETTINGS_ACCESS_ONLY  TUYA_DPID_TWO_BYTE
  c include: ..\..\..\external\NordicSdk_17_0_2\components;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_advertising;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_dtm;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_link_ctx_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_racp;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ancs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ans_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_bas_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_cts_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dis;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_gls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hrs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hts;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_ias_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lbs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_lls;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_nus_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_rscs_c;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_tps;..\..\..\external\NordicSdk_17_0_2\components\ble\common;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_gatt;..\..\..\external\NordicSdk_17_0_2\components\ble\nrf_ble_qwr;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\boards;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_flags;..\..\..\external\NordicSdk_17_0_2\components\libraries\balloc;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bsp;..\..\..\external\NordicSdk_17_0_2\components\libraries\button;..\..\..\external\NordicSdk_17_0_2\components\libraries\cli;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc16;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc32;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense;..\..\..\external\NordicSdk_17_0_2\components\libraries\csense_drv;..\..\..\external\NordicSdk_17_0_2\components\libraries\delay;..\..\..\external\NordicSdk_17_0_2\components\libraries\ecc;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_section_vars;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_task_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\..\external\NordicSdk_17_0_2\components\libraries\gfx;..\..\..\external\NordicSdk_17_0_2\components\libraries\gpiote;..\..\..\external\NordicSdk_17_0_2\components\libraries\hardfault;..\..\..\external\NordicSdk_17_0_2\components\libraries\hci;..\..\..\external\NordicSdk_17_0_2\components\libraries\led_softblink;..\..\..\external\NordicSdk_17_0_2\components\libraries\log;..\..\..\external\NordicSdk_17_0_2\components\libraries\log\src;..\..\..\external\NordicSdk_17_0_2\components\libraries\low_power_pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\mem_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\memobj;..\..\..\external\NordicSdk_17_0_2\components\libraries\mpu;..\..\..\external\NordicSdk_17_0_2\components\libraries\mutex;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwm;..\..\..\external\NordicSdk_17_0_2\components\libraries\pwr_mgmt;..\..\..\external\NordicSdk_17_0_2\components\libraries\queue;..\..\..\external\NordicSdk_17_0_2\components\libraries\ringbuf;..\..\..\external\NordicSdk_17_0_2\components\libraries\scheduler;..\..\..\external\NordicSdk_17_0_2\components\libraries\sdcard;..\..\..\external\NordicSdk_17_0_2\components\libraries\slip;..\..\..\external\NordicSdk_17_0_2\components\libraries\sortlist;..\..\..\external\NordicSdk_17_0_2\components\libraries\spi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\stack_guard;..\..\..\external\NordicSdk_17_0_2\components\libraries\strerror;..\..\..\external\NordicSdk_17_0_2\components\libraries\svc;..\..\..\external\NordicSdk_17_0_2\components\libraries\timer;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_mngr;..\..\..\external\NordicSdk_17_0_2\components\libraries\twi_sensor;..\..\..\external\NordicSdk_17_0_2\components\libraries\uart;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\audio;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\cdc\acm;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\generic;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\kbd;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\hid\mouse;..\..\..\external\NordicSdk_17_0_2\components\libraries\usbd\class\msc;..\..\..\external\NordicSdk_17_0_2\components\libraries\util;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ac_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\common;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\hs_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\generic\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\launchapp;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\message;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\parser\record;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\text;..\..\..\external\NordicSdk_17_0_2\components\nfc\ndef\uri;..\..\..\external\NordicSdk_17_0_2\components\nfc\platform;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t2t_parser;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_lib;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\apdu;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\cc_file;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\hl_detection_procedure;..\..\..\external\NordicSdk_17_0_2\components\nfc\t4t_parser\tlv;..\..\..\external\NordicSdk_17_0_2\components\softdevice\common;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers\nrf52;..\..\..\external\NordicSdk_17_0_2\external\fprintf;..\..\..\external\NordicSdk_17_0_2\external\segger_rtt;..\..\..\external\NordicSdk_17_0_2\external\utf_converter;..\..\..\external\NordicSdk_17_0_2\integration\nrfx;..\..\..\external\NordicSdk_17_0_2\integration\nrfx\legacy;..\..\..\external\NordicSdk_17_0_2\modules\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\drivers\include;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\hal;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\ble\peer_manager;..\..\..\external\NordicSdk_17_0_2\components\ble\ble_services\ble_hids;..\..\..\external\NordicSdk_17_0_2\components\libraries\fds;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\src\config;..\..\src\user_app;..\..\src\user_ble;..\..\src\user_bsp;..\..\src\user_drivers;..\..\src\user_bsp\tiny-AES128;..\..\src\projects;..\..\src\session;..\..\src\cmds;..\..\src\tuya_cmd_management;..\..\src\efsm;..\..\src\projects\WAP-2-413 London;..\..\src\projects\WAP-2-413 London\app;..\..\src\projects\WAP-2-413 London\app\tuya;..\..\src\projects\WAP-2-413 London\bsp;..\..\src\session_sharing
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20009aa0 size 0x36560
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.6.0, Device:Startup 8.35.0, Device:Startup 8.44.1
