# Keil uVision project secure_bootloader_ble_s140_pca10056.uvprojx, settings and files
target nrf52840_xxaa_s140 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10056  FLOAT_ABI_HARD NRF52840_XXAA NRF_DFU_SETTINGS_VERSION=2 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1   __HEAP_SIZE=0
  c misc: --reduce_paths
  c include: ..\..\..\external\NordicSdk_17_0_2\components\ble\common;..\..\..\external\NordicSdk_17_0_2\components\boards;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\balloc;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc32;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\cc310;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\cc310_bl;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\cifra;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\mbedtls;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\micro_ecc;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\nrf_hw;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\nrf_sw;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\oberon;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\optiga;..\..\..\external\NordicSdk_17_0_2\components\libraries\delay;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_section_vars;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\..\external\NordicSdk_17_0_2\components\libraries\log;..\..\..\external\NordicSdk_17_0_2\components\libraries\log\src;..\..\..\external\NordicSdk_17_0_2\components\libraries\mem_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\memobj;..\..\..\external\NordicSdk_17_0_2\components\libraries\mutex;..\..\..\external\NordicSdk_17_0_2\components\libraries\queue;..\..\..\external\NordicSdk_17_0_2\components\libraries\ringbuf;..\..\..\external\NordicSdk_17_0_2\components\libraries\scheduler;..\..\..\external\NordicSdk_17_0_2\components\libraries\stack_info;..\..\..\external\NordicSdk_17_0_2\components\libraries\strerror;..\..\..\external\NordicSdk_17_0_2\components\libraries\svc;..\..\..\external\NordicSdk_17_0_2\components\libraries\util;..\..\..\external\NordicSdk_17_0_2\components\softdevice\common;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers\nrf52;..\..\..\external\NordicSdk_17_0_2\external\fprintf;..\..\..\external\NordicSdk_17_0_2\external\nano-pb;..\..\..\external\NordicSdk_17_0_2\external\nrf_cc310\include;..\..\..\external\NordicSdk_17_0_2\external\nrf_cc310_bl\include;..\..\..\external\NordicSdk_17_0_2\external\nrf_oberon;..\..\..\external\NordicSdk_17_0_2\external\nrf_oberon\include;..\..\..\external\NordicSdk_17_0_2\integration\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\hal;..\..\..\external\NordicSdk_17_0_2\external\micro-ecc\micro-ecc;..\..\..\external\NordicSdk_17_0_2\components\libraries\sha256;..\..\src\config;..\..\src
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_DFU_SETTINGS_VERSION=2 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_DFU_SETTINGS_VERSION=2,-DNRF_DFU_SVCI_ENABLED,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-D__HEAP_SIZE=0
  asm include: ..\..\config;..\..\..\external\NordicSdk_17_0_2\components\ble\common;..\..\..\external\NordicSdk_17_0_2\components\boards;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic;..\..\..\external\NordicSdk_17_0_2\components\libraries\atomic_fifo;..\..\..\external\NordicSdk_17_0_2\components\libraries\balloc;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\ble_dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\bootloader\dfu;..\..\..\external\NordicSdk_17_0_2\components\libraries\crc32;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\cc310;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\cc310_bl;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\cifra;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\mbedtls;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\micro_ecc;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\nrf_hw;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\nrf_sw;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\oberon;..\..\..\external\NordicSdk_17_0_2\components\libraries\crypto\backend\optiga;..\..\..\external\NordicSdk_17_0_2\components\libraries\delay;..\..\..\external\NordicSdk_17_0_2\components\libraries\experimental_section_vars;..\..\..\external\NordicSdk_17_0_2\components\libraries\fstorage;..\..\..\external\NordicSdk_17_0_2\components\libraries\log;..\..\..\external\NordicSdk_17_0_2\components\libraries\log\src;..\..\..\external\NordicSdk_17_0_2\components\libraries\mem_manager;..\..\..\external\NordicSdk_17_0_2\components\libraries\memobj;..\..\..\external\NordicSdk_17_0_2\components\libraries\mutex;..\..\..\external\NordicSdk_17_0_2\components\libraries\queue;..\..\..\external\NordicSdk_17_0_2\components\libraries\ringbuf;..\..\..\external\NordicSdk_17_0_2\components\libraries\scheduler;..\..\..\external\NordicSdk_17_0_2\components\libraries\stack_info;..\..\..\external\NordicSdk_17_0_2\components\libraries\strerror;..\..\..\external\NordicSdk_17_0_2\components\libraries\svc;..\..\..\external\NordicSdk_17_0_2\components\libraries\util;..\..\..\external\NordicSdk_17_0_2\components\softdevice\common;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers;..\..\..\external\NordicSdk_17_0_2\components\softdevice\s140\headers\nrf52;..\..;..\..\..\external\NordicSdk_17_0_2\external\fprintf;..\..\..\external\NordicSdk_17_0_2\external\nano-pb;..\..\..\external\NordicSdk_17_0_2\external\nrf_cc310\include;..\..\..\external\NordicSdk_17_0_2\external\nrf_cc310_bl\include;..\..\..\external\NordicSdk_17_0_2\external\nrf_oberon;..\..\..\external\NordicSdk_17_0_2\external\nrf_oberon\include;..\..\..\external\NordicSdk_17_0_2\integration\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx;..\..\..\external\NordicSdk_17_0_2\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0xf8000 size 0x6000
  memory RVCT9: RAM 0x20005978 size 0x3a688
  link misc: --diag_suppress 6330
  group Application
    ../../src/: dfu_public_key.c main.c
    ../../src/config/: sdk_config.h
  group Board Definition
    ../../../external/NordicSdk_17_0_2/components/boards/: boards.c
  group nRF_BLE
    ../../../external/NordicSdk_17_0_2/components/ble/common/: ble_srv_common.c
  group nRF_Bootloader
    ../../../external/NordicSdk_17_0_2/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    ../../../external/NordicSdk_17_0_2/components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
    ../../../external/NordicSdk_17_0_2/components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend CC310_BL
    ../../../external/NordicSdk_17_0_2/components/libraries/crypto/backend/cc310_bl/: cc310_bl_backend_ecc.c cc310_bl_backend_ecdsa.c cc310_bl_backend_hash.c cc310_bl_backend_init.c cc310_bl_backend_shared.c
  group nRF_Crypto backend Oberon
    ../../../external/NordicSdk_17_0_2/components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend micro_ecc
    ../../../external/NordicSdk_17_0_2/components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    ../../../external/NordicSdk_17_0_2/components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
    ../../../external/NordicSdk_17_0_2/components/libraries/bootloader/ble_dfu/: nrf_dfu_ble.c
  group nRF_Drivers
    ../../../external/NordicSdk_17_0_2/modules/nrfx/hal/: nrf_nvmc.c
    ../../../external/NordicSdk_17_0_2/modules/nrfx/soc/: nrfx_atomic.c
  group nRF_Libraries
    ../../../external/NordicSdk_17_0_2/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../external/NordicSdk_17_0_2/components/libraries/scheduler/: app_scheduler.c
    ../../../external/NordicSdk_17_0_2/components/libraries/crc32/: crc32.c
    ../../../external/NordicSdk_17_0_2/components/libraries/mem_manager/: mem_manager.c
    ../../../external/NordicSdk_17_0_2/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../external/NordicSdk_17_0_2/components/libraries/atomic/: nrf_atomic.c
    ../../../external/NordicSdk_17_0_2/components/libraries/balloc/: nrf_balloc.c
    ../../../external/NordicSdk_17_0_2/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../external/NordicSdk_17_0_2/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../external/NordicSdk_17_0_2/components/libraries/memobj/: nrf_memobj.c
    ../../../external/NordicSdk_17_0_2/components/libraries/queue/: nrf_queue.c
    ../../../external/NordicSdk_17_0_2/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../external/NordicSdk_17_0_2/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../external/NordicSdk_17_0_2/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../external/NordicSdk_17_0_2/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../../../external/NordicSdk_17_0_2/external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_3.0.6.lib
  group nRF_SVC
    ../../../external/NordicSdk_17_0_2/components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    ../../../external/NordicSdk_17_0_2/components/libraries/svc/: nrf_svc_handler.c
  group nRF_SoftDevice
    ../../../external/NordicSdk_17_0_2/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nano-pb
    ../../../external/NordicSdk_17_0_2/external/nano-pb/: pb_common.c pb_decode.c
  group nrf_cc310_bl
    ../../../external/NordicSdk_17_0_2/external/nrf_cc310_bl/lib/cortex-m4/hard-float/short-wchar/: nrf_cc310_bl_0.9.13.lib
  group micro-ecc
    ../../../external/NordicSdk_17_0_2/external/micro-ecc/nrf52hf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group sha256
    ../../../external/NordicSdk_17_0_2/components/libraries/sha256/: sha256.c
target flash_s140_nrf52_7.2.0_softdevice (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: s140_nrf52_7.2.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=0
  c misc: --reduce_paths
  c include: ..\..\config;..\config
  asm define: __HEAP_SIZE=0
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=0
  asm include: ..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0xf8000 size 0x6000
  memory RVCT9: RAM 0x20005978 size 0x3a688
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
